# Repository jediminer543/animated-robot

File README.md:

# animated-robot
Easily PCBA-able BLDC driver

## KiCad design hardware/linkodrive08/linkodrive08.kicad_pcb

Parts:
C1, C7, C8, C9, C34: 100n; C_0603_1608Metric; LCSC C14663
C2, C21, C22, C35: 1n; C_0603_1608Metric; LCSC C1588
C3, C4, C10, C26: 10u; C_0805_2012Metric; LCSC C440198
C5, C6, C28: 470n; C_0805_2012Metric; Tolerances 15V; LCSC C13967
C11, C12, C13, C14, C30, C31: Cg; C_0603_1608Metric; Tolerances 15V; not fitted
C15, C36: 4u7; C_0603_1608Metric; LCSC C19666
C16, C17: 18p; C_0402_1005Metric; LCSC C1549
C18, C19, C33, C38: Cs; C_0603_1608Metric
C20, C23, C24: 100u; C_Elec_10x10.2; Tolerances 50V; LCSC C487440
C25: 100u; C_1206_3216Metric; not fitted
C27: 100u; CP_Elec_6.3x7.7; Tolerances 15V; LCSC C5155339
C29: 10u; C_1206_3216Metric; Tolerances 15V; LCSC C13585
C32: 2u2; C_0805_2012Metric; Tolerances 50V; LCSC C2981733
C37: 2u2; C_0805_2012Metric; Tolerances 15V; LCSC C377773
D1: LED_G; LED_0805_2012Metric; LCSC C2297
D2: LED_R; LED_0603_1608Metric; LCSC C2286
D3, D4, D9, D12: DSK310; D_SOD-123F; LCSC C28646289
D5, D6, D7, D8, D10, D11: ES2JW; D_SOD-123F; LCSC C353499
D13: D_Clamp; D_SOD-123; LCSC C28646289
D14, D15, D16: LED_Y; LED_0603_1608Metric; LCSC C72038
J1: VBUS; TestPoint_Plated_Hole_D4.0mm
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV; LCSC C2765186
J3: GATE_DRIVE; PinSocket_1x02_P2.54mm_Vertical
J4: LOGIC_POWER; PinSocket_1x02_P2.54mm_Vertical
J5: LKS_SIF; PinSocket_1x03_P2.54mm_Vertical; not fitted
J6: LKS_IO; PinSocket_1x05_P2.54mm_Vertical; not fitted
J7: LKS_SPI; PinSocket_1x06_P2.54mm_Vertical; not fitted
J8: CAN; PinSocket_1x02_P2.54mm_Vertical; not fitted
J9: WCH_SWD; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J10: ENC; PinSocket_1x05_P2.54mm_Vertical
J11: LKS_I2C; PinSocket_1x04_P2.54mm_Vertical; not fitted
J12: LKS_SWD; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J13: HALL; PinSocket_1x05_P2.54mm_Vertical
J14: MOT_U; TestPoint_Plated_Hole_D4.0mm
J15: MOT_V; TestPoint_Plated_Hole_D4.0mm
J16: MOT_W; TestPoint_Plated_Hole_D4.0mm
J17: WCH_GPIO; PinSocket_2x05_P2.54mm_Vertical; not fitted
J18: WCH_UART_ALT; PinSocket_1x04_P2.54mm_Vertical; not fitted
J19: GND; TestPoint_Plated_Hole_D4.0mm
JP1: TX_JP; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
JP2: RX_JP; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
JP3: VBUS_ISO; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
JP4: VDrive_ISO; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
L1: 47u; L_Taiyo-Yuden_NR-60xx; LCSC C497831
L2: 10uH; L_Changjiang_FNR5040S; LCSC C167967
NT1, NT2, NT3, NT4, NT5, NT6, NT7, NT8, NT9, NT10, NT11: NT; NetTie-2_SMD_Pad0.5mm
Q1, Q2, Q3, Q4, Q5, Q6: JMTK80N06A; TO-252-2; LCSC C3031548
R1, R4, R7, R26, R28, R41, R48, R49, R50, R51, R52, R53: 1k; R_0603_1608Metric; LCSC C21190
R2, R3: 5k1; R_0603_1608Metric; LCSC C23186
R5, R29, R45: 10k; R_0603_1608Metric; LCSC C25804
R6, R25, R27, R40: 39k; R_0603_1608Metric; LCSC C23153
R8: 0R; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
R9, R10, R32: 4R7; R_0603_1608Metric; LCSC C23164
R11, R12, R13, R14, R33, R34: 51R; R_0603_1608Metric; LCSC C23197
R15, R16, R17, R18, R35, R36: 10R; R_0603_1608Metric; LCSC C22859
R19, R20, R31, R37: 5m; R_2512_6332Metric; LCSC C393074
R21, R22, R23, R24, R38, R39, R46, R47: Rs; R_0603_1608Metric
R30: 100k; R_0603_1608Metric; LCSC C25803
R42: 33k; R_0603_1608Metric; LCSC C4216
R43: 20k; R_0603_1608Metric; LCSC C4184
R44: 120k; R_0603_1608Metric; LCSC C25808
TP1: VBAT_MES; TestPoint_Pad_1.5x1.5mm
TP2: WCH_VTST; TestPoint_Pad_1.5x1.5mm
TP3: LKS_3V3TST; TestPoint_Pad_1.5x1.5mm
TP4: LKS_VTST; TestPoint_Pad_1.5x1.5mm
TP5: LKS_TX; TestPoint_Pad_1.5x1.5mm
TP6: LKS_RX; TestPoint_Pad_1.5x1.5mm
U1: LKS32MC086NxQx; QFN-52-1EP_6x6mm_P0.4mm_EP4.5x4.5mm_ThermalVias; LCSC C2798413
U2: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C12084
U3: CH32V203G6U6; QFN-28-1EP_4x4mm_P0.4mm_EP2.6x2.6mm_ThermalVias; LCSC C5142280
U4: XL1509-ADJ; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C74192
U5: LGS5145; SOT-23-6; LCSC C5123971
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9002

Connections:
+3V3: C7.1, C8.1, C9.1, C10.1, C25.1, C36.1, D14.2 (A), J4.1, J5.3, J6.1, J7.6, J9.1, J10.1, J11.4, J12.1, J13.1, J17.1, J18.1, L1.2, R5.1, R42.1, TP2.1, TP3.1, U1.3 (AVDD), U2.3 (VCC), U3.5 (VDDA), U3.17 (VDD)
/CAN_RX: U1.7 (P0.6), U2.4 (R)
/CAN_TX: U1.8 (P0.7), U2.1 (D)
/DAC: J6.3, U1.1 (P0.0)
/ENC_A: J10.2, U1.9 (P2.11)
/ENC_B: J10.3, U1.10 (P2.12)
/ENC_I: J10.5, U1.52 (P2.15)
/HALL_U: J13.2, U1.47 (P2.4)
/HALL_V: J13.3, U1.48 (P2.5)
/HALL_W: J13.4, U1.49 (P2.6)
/HO1: D10.1 (K), R33.1, U1.27 (HO1)
/HO2: D5.1 (K), R11.1, U1.30 (HO2)
/HO3: D7.1 (K), R13.1, U1.33 (HO3)
/I2C_SCL: J11.3, U1.36 (P1.10)
/I2C_SDA: J11.2, U1.41 (P2.10)
/ISENSE_TOT+: C38.1, R46.1, U1.43 (P3.15)
/ISENSE_TOT-: C38.2, R47.1, U1.42 (P3.14)
/ISENSE_U+: C33.1, R38.1, U1.17 (P3.5)
/ISENSE_U-: C33.2, R39.1, U1.18 (P3.7)
/ISENSE_V+: C18.1, R21.1, U1.20 (P3.0)
/ISENSE_V-: C18.2, R22.1, U1.21 (P3.1)
/ISENSE_W+: C19.1, R23.1, U1.38 (P3.10)
/ISENSE_W-: C19.2, R24.1, U1.39 (P3.11)
/LED0: D1.2 (A), U1.4 (P0.3)
/LED1: D2.2 (A), U1.5 (P0.4)
/LKS_SWCLK: J12.4, U1.50 (SWCLK), U3.11 (PA5)
/LKS_SWDIO: J12.2, R8.1, U1.51 (SWDIO/P2.14), U3.12 (PA6)
/LKS_~RST: J12.3, U1.2 (~RST/P0.2), U3.7 (PA1)
/LO1: D11.1 (K), R34.1, U1.23 (LO1)
/LO2: D6.1 (K), R12.1, U1.24 (LO2)
/LO3: D8.1 (K), R14.1, U1.25 (LO3)
/MOT1: C30.2, J14.1, NT9.2, Q5.3 (S), Q6.2 (D)
/MOT1_MEAS: C28.2, NT9.1, R40.1, U1.26 (VS1)
/MOT2: C11.2, J15.1, NT1.2, Q1.3 (S), Q2.2 (D)
/MOT2_MEAS: C5.2, NT1.1, R25.1, U1.29 (VS2)
/MOT3: C13.2, J16.1, NT2.2, Q3.3 (S), Q4.2 (D)
/MOT3_MEAS: C6.2, NT2.1, R27.1, U1.32 (VS3)
/P2.2: J6.4, U1.45 (P2.2)
/P2.7_LDO15: J6.2, U1.19 (P2.7)
/PA0: J17.3, U3.6 (PA0)
/PA4: J17.5, U3.10 (PA4)
/PA15: J17.7, U3.23 (PA15)
/PB0: J17.4, U3.14 (PB0)
/PB1: J17.6, U3.15 (PB1)
/PB3: J17.8, U3.24 (PB3)
/PB4: J17.10, U3.25 (PB4)
/PB5: J17.9, U3.26 (PB5)
/P_IST+: NT8.2, R46.2
/P_IST-: NT7.1, R47.2
/P_ISU+: NT10.2, R38.2
/P_ISU-: NT11.2, R39.2
/P_ISV+: NT3.2, R21.2
/P_ISV-: NT4.2, R22.2
/P_ISW+: NT5.2, R23.2
/P_ISW-: NT6.2, R24.2
/SIF: J5.2, U1.14 (P0.14)
/SPI_CLK: J7.5, U1.44 (P2.1)
/SPI_CS: J7.2, U1.46 (P2.3)
/SPI_DI: J7.4, U1.16 (P1.0)
/SPI_DO: J7.3, U1.40 (P2.9)
/UART_ALT_RX: J18.3, U3.9 (PA3)
/UART_ALT_TX: J18.2, U3.8 (PA2)
/UART_FROM_WCH: JP1.2 (B), U3.27 (PB6)
/UART_RX: JP1.1 (A), TP6.1, U1.37 (P1.11)
/UART_TO_WCH: JP2.2 (B), U3.28 (PB7)
/UART_TX: JP2.1 (A), TP5.1, U1.15 (P0.15)
/USB_D+: J2.A6 (D+), J2.B6 (D+), U3.20 (PA12/USB_D+)
/USB_D-: J2.A7 (D-), J2.B7 (D-), U3.19 (PA10/PA11/USB_D-)
/USB_VBUS: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U3.18 (PA9)
/VB1: C28.1, R32.2, U1.28 (VB1)
/VB2: C5.1, R9.2, U1.31 (VB2)
/VB3: C6.1, R10.2, U1.34 (VB3)
/VBATT_MEAS: C2.1, R6.2, R7.1, TP1.1, U1.6 (P0.5)
/V_U: C35.1, R40.2, R41.1, U1.11 (P0.11)
/V_V: C21.1, R25.2, R26.1, U1.12 (P0.12)
/V_W: C22.1, R27.2, R28.1, U1.13 (P0.13)
/WCH_BOOT0: J9.6, R29.1, U3.1 (BOOT0/PB8)
/WCH_SWCLK: J9.4, U3.22 (PA14/SWCLK)
/WCH_SWDIO: J9.2, U3.21 (PA13/SWDIO)
/WCH_~RST: C1.1, J9.3, R5.2, U3.4 (~RST)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C15.2, C16.2, C17.2, C21.2, C22.2, C25.2, C26.2, C27.2, C29.2, C32.2, C35.2, C36.2, C37.1, D12.2 (A), D13.2 (A), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.2, J4.2, J5.1, J6.5, J7.1, J9.5, J10.4, J11.1, J12.5, J13.5, J17.2, J18.4, J19.1, NT7.2, R1.2, R2.2, R3.2, R4.2, R7.2, R26.2, R28.2, R29.2, R31.1, R41.2, R43.2, R45.2, R48.1, R49.1, R51.1, U1.53 (GND), U2.2 (GND), U2.8 (Rs), U3.16 (VSS), U3.29 (VSS), U4.4 (~EN), U4.5 (GND), U4.6 (GND), U4.7 (GND), U4.8 (GND), U5.2 (GND), Y1.2, Y1.4
GNDPWR: C12.2, C14.2, C20.2, C23.2, C24.2, C31.2, NT4.1, NT6.1, NT8.1, NT11.1, R19.2, R20.2, R30.2, R31.2, R37.2
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R4.1
unnamed: D3.1 (K), R9.1
unnamed: D4.1 (K), R10.1
unnamed: D5.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: D7.2 (A), R17.1
unnamed: D8.2 (A), R18.1
unnamed: D9.1 (K), R32.1
unnamed: D10.2 (A), R35.1
unnamed: D11.2 (A), R36.1
unnamed: D12.1 (K), L1.1, U4.2 (OUT)
unnamed: C34.2, D13.1 (K), L2.1, U5.6 (SW)
unnamed: D14.1 (K), R48.2
unnamed: D15.1 (K), R52.2
unnamed: D16.1 (K), R50.2
unnamed: J2.A5 (CC1), R3.1
unnamed: J2.B5 (CC2), R2.1
unnamed: J8.1, U2.7 (CANH)
unnamed: J8.2, U2.6 (CANL)
unnamed: C32.1, JP3.1 (A), U5.4 (EN), U5.5 (VIN)
unnamed: JP4.1 (A), L2.2, R44.1
unnamed: C11.1, Q1.1 (G), R11.2, R15.2
unnamed: C12.1, Q2.1 (G), R12.2, R16.2
unnamed: NT3.1, Q2.3 (S), R19.1
unnamed: C13.1, Q3.1 (G), R13.2, R17.2
unnamed: C14.1, Q4.1 (G), R14.2, R18.2
unnamed: NT5.1, Q4.3 (S), R20.1
unnamed: C30.1, Q5.1 (G), R33.2, R35.2
unnamed: C31.1, Q6.1 (G), R34.2, R36.2
unnamed: NT10.1, Q6.3 (S), R37.1
unnamed: R49.2, R52.1
unnamed: R50.1, R53.2
unnamed: R51.2, R53.1
unnamed: C16.1, U3.2 (OSC_IN/PD0), Y1.3
unnamed: C17.1, U3.3 (OSC_OUT/PD1), Y1.1
unnamed: R8.2, U3.13 (PA7)
unnamed: R42.2, R43.1, U4.3 (FB)
unnamed: C34.1, U5.1 (BST)
unnamed: R44.2, R45.1, U5.3 (FB)
VBUS: C20.1, C23.1, C24.1, D16.2 (A), J1.1, JP3.2 (B), Q1.2 (D), Q3.2 (D), Q5.2 (D), R6.1, R30.1
Vdrive: C3.1, C4.1, C15.1, C26.1, C27.1, C29.1, C37.2, D3.2 (A), D4.2 (A), D9.2 (A), D15.2 (A), J3.1, JP4.2 (B), TP4.1, U1.22 (VCC), U4.1 (VIN)

Notes on the sheet:
Logic Voltage 3V3 ONLY Output only
SIF Some one wire comms protocol Usually talks to LCDs?
Place R and C near MCU
left a UART free for debug maybe?
Spec'd for ~160kHz cutoff
xxx how do we calculate proper delta I_L for DCM? forgor with the usual CCM calculations get < ~600 mA and a minimum output cap of 1.6 uF
Place 1 per driver phase discharge resistor wherever
WCH Programming
Not populated due to cost
UART Test Points
NOTE PA9 is 5V tolerant
UART_JP
稳压器电源输入。使用2.2uF或更大的陶瓷贴片尽量近旁路VIN至GND。 > Use a 2.2uF MLCC as close to VIN-GND as possible
WCH
SPI lines hard to allocate
design note: these pins are usable for either uart or i2c less valuable (fewer AF) than pa2/pa3
Route signals differentially
xxx todo
Left Intentionally Blank
Should be able to use TagConnect or equiv
LKS I2C Free for fun
Motor Drive Phase W
Possible other transistor options: - HSU6066 - C22359249 - TO-252 - WSD4070DN - C719095 - DFN3X3-8L - JMTK80N06A - C3031548 - TO-252-4R
can use spi if we want, else bitbang
do we need this capacitor? maybe for a motor driver
Route Differentially
Voltage TSTs place near assoc. components
Remuxable in software
Encoder Input
This device is self powered and NOT bus powered
Voltage Sensing
Motor Drive Power Mosfet Limited
Part is calculatable with kicad calculator VREF=0.812
I2C lines chosen as they have internal pullups
cost optimize for jlc output = 3.26 V
LKS
This is a dev board and is both subject to change and may not work
General bulk cap
3V3 Regulator
Netsplits needed to allow differential routing

Board: 4 copper layers, 67.2 x 90.4 mm, 161 parts (9 on the bottom side), 124 nets.

## KiCad design hardware/initial-driver/initial-driver.kicad_pcb

Board: 2 copper layers, 8 parts (0 on the bottom side), 8 nets.

Parts:
J4: USB_C; USB_C_Receptacle_Palconn_UTC16-G
Q1: UFET; PDFN8L
Q2: VFET; PDFN8L
Q3: WFET; PDFN8L
U1: ESP32-S3-WROOM-1
U2, U3: TPS54260; MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm
U4: PT5616A; SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
+5V: J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS)
/D+: J4.A6 (D+), J4.B6 (D+), U1.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+)
/D-: J4.A7 (D-), J4.B7 (D-), U1.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-)
/Phase Drive/PHASE_U: Q1.1 (S), Q1.6 (D), U4.26 (VSU)
/Phase Drive/PHASE_V: Q2.1 (S), Q2.6 (D), U4.22 (VSV)
/Phase Drive/PHASE_W: Q3.1 (S), Q3.6 (D), U4.18 (VSW)
GND: J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.9 (GND), U2.11 (GND), U3.9 (GND), U3.11 (GND), U4.12 (VSS)
VBUS: Q1.5 (D), Q2.5 (D), Q3.5 (D), U3.2 (VIN)

## Commit log

2024-01-09 Initial work on schematic and stuff
2024-01-13 Refactor current sensing
2024-01-20 updated more stuff
2024-03-29 add more stuff
2024-03-29 working on a new version
2024-03-30 add CH32V203 symbol
2024-03-30 copy LKS32 symbol
2024-03-30 hopefully more/mostly KLC compliant
2024-03-30 throw mcus onto sch
2024-03-30 wch usb bridge section
2024-03-30 lks32 digital section
    also realize we don't want LDO version
2024-03-30 hbridge something like this?
2024-03-30 have a poke
2024-03-30 fixes to pin assignment
2024-03-30 fix wch usb vbus det
2024-03-30 add capacitor on wch reset
2024-03-30 buck converter, after much frustration
2024-03-30 settle on a h-bridge design
2024-07-15 work on newer linkosemi driver +tidyup
2024-07-22 Work on schematic; changing buck
2024-07-23 work on design
2024-08-08 Work on schematic
2024-08-08 Mostly Finalise Schematic
2024-08-08 Work on footprints
2024-08-18 Work on component selection
2024-08-19 schematic rework and more parts
2024-08-20 Initial PCB work
2024-08-26 Work on pcb and some parts changes
2024-09-03 more work on PCB
2024-09-05 Finish layout
2024-09-05 Add power indicator LEDs
2024-09-05 Setup thermal relief on most parts
2024-09-05 more stuf
2024-09-06 add dimension markers
2024-09-07 changes?
